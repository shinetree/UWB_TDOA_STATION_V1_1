# Keil uVision project UWB_STATION_V1_1.uvprojx, settings and files
target TREK1000 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: test +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\SPI;..\HARDWARE\application;..\HARDWARE\decadriver;..\HARDWARE\platform;..\HARDWARE\compiler;..\HARDWARE\PORT;..\HARDWARE\stm32flash;..\HARDWARE\DMA;..\USB\lib;..\USB\src;..\Public;..\HARDWARE\W5500;..\FreeRTOS\Source\portable\Keil\ARM_CM3;..\FreeRTOS\Source\portable\MemMang;..\FreeRTOS\Source;..\FreeRTOS\Source\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group application
    ../HARDWARE/application/: instance.c instance_calib.c instance_common.c
  group decadriver
    ../HARDWARE/decadriver/: deca_device.c deca_params_init.c deca_range_tables.c
  group platform
    ../HARDWARE/platform/: deca_mutex.c deca_spi.c device_info.c
  group USER
    ./: main.c stm32f10x_it.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/PORT/: port.c
    ../HARDWARE/stm32flash/: stmflash.c
    ../HARDWARE/W5500/: W5500.c
  group USB
    ../USB/src/: hw_config.c usb_desc.c usb_endp.c usb_istr.c usb_it.c usb_prop.c usb_pwr.c
  group USB/Lib
    ../USB/lib/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
    ../HARDWARE/DMA/: dma.c
    ../Public/: queue_user.c
    ../STM32F10x_FWLib/src/: stm32f10x_tim.c
  group FREERTOS
    ../FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../FreeRTOS/Source/portable/Keil/ARM_CM3/: port.c
software components: CMSIS:CORE 4.3.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:DMA 3.5.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:Flash 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:SPI 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
